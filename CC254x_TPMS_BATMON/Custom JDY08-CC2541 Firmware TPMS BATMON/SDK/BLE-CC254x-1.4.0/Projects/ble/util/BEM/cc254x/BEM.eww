<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\BEM.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>BEM</project>
        <configuration>CC254xF256</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


