# IAR project UBL.ewp, settings and files
configuration CC2540-DK (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2540F256.i51
  ICC8051.CCDefines: HAL_SB_BOOT_CODE; UBL_BUILD
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\app; ..\hal; ..\hal\usb\; ..\hal\usb\class_msd; ..\hal\usb\library
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: ubl.xcl
configuration CC2540-Nano (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: HAL_SB_BOOT_CODE; HAL_DONGLE_NANO; UBL_BUILD
  group App
    ../app/: ubl_exec.c ubl_exec.h ubl_ivec.s51 ubl_main.c
    ./: ubl_link.xcl
  group HAL
    ../hal/: hal_board_cfg.h hal_defs.h hal_dma.h hal_flash.c hal_flash.h hal_mcu.h hal_types.h
  group HAL/USB
    ../hal/usb/: usb_board_cfg.h usb_interrupt.c usb_suspend.c
  group HAL/USB/library
    ../hal/usb/library/: usb_descriptor.h usb_descriptor_parser.c usb_descriptor_parser.h usb_framework.c usb_framework.h usb_framework_structs.h usb_interrupt.h usb_reg.h usb_standard_requests.c usb_standard_requests.h usb_suspend.h
    ../hal/usb/class_msd/: usb_msd_8051.lib
