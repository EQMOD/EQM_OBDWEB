# IAR project EBL.ewp, settings and files
configuration CC254x_UART0_ALT1 (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2541F256.i51
  ICC8051.CCDefines: HAL_AES_DMA=FALSE; HAL_UART_SBL=1; SBL_UART_PORT=HAL_UART_PORT_0; xPOWER_SAVING
  ICC8051.CCDiagSuppress: Pe177
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\..\app; ..\..\app\cc254x; ..\..\..\..\..\..\Components\hal\target\CC2540EB; ..\..\..\..\..\..\Components\hal\target\_common\cc2540; ..\..\..\..\..\..\Components\hal\include; ..\..\..\..\..\..\Components\osal\include
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: sbl_cc254x.xcl
  group Application
    ../../app/: sbl_exec.c sbl_exec.h sbl_main.c
    ../../app/cc254x/: sbl_ivec.s51
  group HAL/Include
    ../../../../../../Components/hal/include/: hal_adc.h hal_defs.h hal_flash.h hal_rpc.h hal_uart.h
  group HAL/Target/CC2540EB
    ../../../../../../Components/hal/target/CC2540EB/: hal_adc.c hal_aes.c hal_aes.h hal_board_cfg.h hal_flash.c hal_mcu.h hal_types.h
